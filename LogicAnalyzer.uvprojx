# Keil uVision project LogicAnalyzer.uvprojx, settings and files
target LogicAnalyzer (ARM-ADS)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LogicAnalyzer
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F4xx USE_STDPERIPH_DRIVER STM32F429_439xx
  c include: .\ub_lalib;.\ub_lib;.\ub_lib\usb_cdc_lolevel;.\cmsis_lib\include;.\cmsis_boot;.\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0xd0100000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis_boot
    ./cmsis_boot/startup/arm/: startup_stm32f429xx.s
    ./cmsis_boot/: system_stm32f4xx.c
  group cmsis_lib
    ./cmsis_lib/source/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c
  group ub_lalib
    ./ub_lalib/: com.c la.c main.c
  group ub_lib
    ./ub_lib/: stm32_ub_din_dma.c stm32_ub_led.c stm32_ub_sdram.c stm32_ub_systick.c stm32_ub_usb_cdc.c
  group ub_lib/usb_cdc_lolevel
    ./ub_lib/usb_cdc_lolevel/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
