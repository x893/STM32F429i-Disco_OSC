# Keil uVision project Oszi.uvprojx, settings and files
target Oszi (ARM-ADS)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Oszi
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F4xx USE_STDPERIPH_DRIVER STM32F429_439xx ARM_MATH_CM4 __FPU_USED __FPU_PRESENT=1
  c include: .\uboszi_lib;.\ub_lib;.\cmsis_lib\include;.\cmsis_boot;.\cmsis;.\fft_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0xd0100000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group uboszi_lib
    ./uboszi_lib/: oszi.c menu.c adc.c fft.c
  group ub_lib
    ./ub_lib/: stm32_ub_button.c stm32_ub_font.c stm32_ub_graphic2d.c stm32_ub_i2c3.c stm32_ub_lcd_ili9341.c stm32_ub_led.c stm32_ub_sdram.c stm32_ub_spi5.c stm32_ub_systick.c stm32_ub_touch_stmpe811.c stm32_ub_uart.c
  group ub_lib/font
    ./ub_lib/font/: ub_font_arial_7x10.c
  group ub_lib/bilder
    ./ub_lib/bilder/: GUI1.c GUI2.c
  group cmsis_lib
    ./cmsis_lib/source/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group cmsis_boot
    ./cmsis_boot/startup/arm/: startup_stm32f429xx.s
    ./cmsis_boot/: system_stm32f4xx.c
  group fft_lib
    ./fft_lib/: arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cmplx_mag_f32.c arm_common_tables.c arm_max_f32.c arm_rfft_f32.c arm_rfft_init_f32.c
